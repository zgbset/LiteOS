# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target Huawei_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,WITH_AT_FRAMEWORK,USE_NB_NEUL95_NO_ATINY
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\..\arch\arm\arm-m\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\OS_CONFIG;..\..\..\include;..\..\..\demos;..\Hardware\Inc;..\..\..\components\fs\include;..\..\..\components\fs\fatfs\ff13b\source;..\..\..\components\fs\fatfs\ff13b\source\default;..\..\..\tests\cmockery\src\google
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c usart.c stm32l4xx_it.c main.c gpio.c i2c.c stm32l4xx_SixCubicT.c user_task.c dal_usart.c fatfs_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c.c stm32l4xx_hal_uart.c stm32l4xx_hal_rcc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_tim_ex.c
  group Kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
  group Arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group OS_Depends
    ../../../osdepends/liteos/: atiny_osdep.c
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group AT_NBIOT
    ../../../components/connectivity/nb_iot/: los_nb_api.c
    ../../../components/net/at_frame/: at_main.c
    ../../../components/net/at_device/nb_bc95/: bc95.c
    ../Src/: at_hal.c
  group demos
    ../../../demos/nbiot_without_atiny/: nb_demo.c sota_demo.c sht21_demo.c
  group lib
    ../../../components/lib/libc/: malloc.c errno.c
  group Hardware
    ../Hardware/Src/: hal_flash.c
  group fs
    ../../../components/fs/vfs/: los_vfs.c
    ../../../components/fs/fatfs/: los_fatfs.c
    ../../../components/fs/fatfs/ff13b/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group test
    ../../../tests/cmockery/src/: cmockery.c
    ../../../tests/test_suit/: fs_test.c
software components: CMSIS:CORE 4.3.0
